# IAR project BlinkLED3.ewp, settings and files
configuration BlinkLED3 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F767ZI ST STM32F767ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 7
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F767xx
  ICCARM.CCIncludePath2: ../Core/Inc; ../LWIP/App; ../LWIP/Target; ../USB_DEVICE/App; ../USB_DEVICE/Target; /home/jim_agerris/STM32Cube/Repository/STM32Cube_FW_F7_V1.16.1/Middlewares/Third_Party/LwIP/src/include; /home/jim_agerris/STM32Cube/Repository/STM32Cube_FW_F7_V1.16.1/Middlewares/Third_Party/LwIP/system; /home/jim_agerris/STM32Cube/Repository/STM32Cube_FW_F7_V1.16.1/Drivers/STM32F7xx_HAL_Driver/Inc; /home/jim_agerris/STM32Cube/Repository/STM32Cube_FW_F7_V1.16.1/Drivers/STM32F7xx_HAL_Driver/Inc/Legacy; /home/jim_agerris/STM32Cube/Repository/STM32Cube_FW_F7_V1.16.1/Middlewares/Third_Party/LwIP/src/include/netif/ppp; /home/jim_agerris/STM32Cube/Repository/STM32Cube_FW_F7_V1.16.1/Middlewares/ST/STM32_USB_Device_Library/Core/Inc; /home/jim_agerris/STM32Cube/Repository/STM32Cube_FW_F7_V1.16.1/Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc; /home/jim_agerris/STM32Cube/Repository/STM32Cube_FW_F7_V1.16.1/Drivers/CMSIS/Device/ST/STM32F7xx/Include; /home/jim_agerris/STM32Cube/Repository/STM32Cube_FW_F7_V1.16.1/Middlewares/Third_Party/LwIP/src/include/lwip; /home/jim_agerris/STM32Cube/Repository/STM32Cube_FW_F7_V1.16.1/Middlewares/Third_Party/LwIP/src/include/lwip/apps; /home/jim_agerris/STM32Cube/Repository/STM32Cube_FW_F7_V1.16.1/Middlewares/Third_Party/LwIP/src/include/lwip/priv; /home/jim_agerris/STM32Cube/Repository/STM32Cube_FW_F7_V1.16.1/Middlewares/Third_Party/LwIP/src/include/lwip/prot; /home/jim_agerris/STM32Cube/Repository/STM32Cube_FW_F7_V1.16.1/Middlewares/Third_Party/LwIP/src/include/netif; /home/jim_agerris/STM32Cube/Repository/STM32Cube_FW_F7_V1.16.1/Middlewares/Third_Party/LwIP/src/include/compat/posix; /home/jim_agerris/STM32Cube/Repository/STM32Cube_FW_F7_V1.16.1/Middlewares/Third_Party/LwIP/src/include/compat/posix/arpa; /home/jim_agerris/STM32Cube/Repository/STM32Cube_FW_F7_V1.16.1/Middlewares/Third_Party/LwIP/src/include/compat/posix/net; /home/jim_agerris/STM32Cube/Repository/STM32Cube_FW_F7_V1.16.1/Middlewares/Third_Party/LwIP/src/include/compat/posix/sys; /home/jim_agerris/STM32Cube/Repository/STM32Cube_FW_F7_V1.16.1/Middlewares/Third_Party/LwIP/src/include/compat/stdc; /home/jim_agerris/STM32Cube/Repository/STM32Cube_FW_F7_V1.16.1/Middlewares/Third_Party/LwIP/system/arch; /home/jim_agerris/STM32Cube/Repository/STM32Cube_FW_F7_V1.16.1/Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: BlinkLED3.hex
  ILINK.IlinkOutputFile: BlinkLED3.out
  ILINK.IlinkIcfFile: stm32f767xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32f767xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c usart.c stm32f7xx_it.c stm32f7xx_hal_msp.c
  group Application/User/LWIP/App
    ../LWIP/App/: lwip.c
  group Application/User/LWIP/Target
    ../LWIP/Target/: ethernetif.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f7xx.c
  group Drivers/STM32F7xx_HAL_Driver
    /home/jim_agerris/STM32Cube/Repository/STM32Cube_FW_F7_V1.16.1/Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_eth.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_cortex.c stm32f7xx_hal.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_exti.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_ll_usb.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_uart_ex.c
  group Middlewares/LwIP
    /home/jim_agerris/STM32Cube/Repository/STM32Cube_FW_F7_V1.16.1/Middlewares/Third_Party/LwIP/src/netif/ppp/: auth.c ccp.c chap_ms.c chap-md5.c chap-new.c demand.c eap.c eui64.c fsm.c ipcp.c ipv6cp.c lcp.c magic.c mppe.c multilink.c ppp.c pppapi.c pppcrypt.c pppoe.c pppol2tp.c pppos.c upap.c utils.c vj.c ecp.c
    /home/jim_agerris/STM32Cube/Repository/STM32Cube_FW_F7_V1.16.1/Middlewares/Third_Party/LwIP/src/netif/: bridgeif.c bridgeif_fdb.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c slipif.c zepif.c
    /home/jim_agerris/STM32Cube/Repository/STM32Cube_FW_F7_V1.16.1/Middlewares/Third_Party/LwIP/src/api/: err.c if_api.c api_msg.c netbuf.c api_lib.c netifapi.c sockets.c netdb.c tcpip.c
    /home/jim_agerris/STM32Cube/Repository/STM32Cube_FW_F7_V1.16.1/Middlewares/Third_Party/LwIP/src/core/: raw.c tcp.c pbuf.c timeouts.c ip.c inet_chksum.c tcp_out.c netif.c altcp_tcp.c dns.c altcp.c memp.c udp.c stats.c tcp_in.c def.c altcp_alloc.c sys.c init.c mem.c
    /home/jim_agerris/STM32Cube/Repository/STM32Cube_FW_F7_V1.16.1/Middlewares/Third_Party/LwIP/src/core/ipv4/: ip4_frag.c autoip.c dhcp.c ip4.c icmp.c etharp.c ip4_addr.c igmp.c
    /home/jim_agerris/STM32Cube/Repository/STM32Cube_FW_F7_V1.16.1/Middlewares/Third_Party/LwIP/src/core/ipv6/: icmp6.c ip6.c inet6.c dhcp6.c nd6.c mld6.c ip6_addr.c ethip6.c ip6_frag.c
    /home/jim_agerris/STM32Cube/Repository/STM32Cube_FW_F7_V1.16.1/Middlewares/Third_Party/LwIP/src/apps/mqtt/: mqtt.c
  group Middlewares/USB_Device_Library
    /home/jim_agerris/STM32Cube/Repository/STM32Cube_FW_F7_V1.16.1/Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    /home/jim_agerris/STM32Cube/Repository/STM32Cube_FW_F7_V1.16.1/Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
